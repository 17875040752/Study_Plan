# Keil uVision project Fire_FreeRTOS.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: YH-RT-Thread
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\User;..\freertos\include;..\freertos\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ../User/: main.c
  group FreeRTOS/Ports
    ../freertos/portable/RVDS/ARM_CM4/: port.c
  group FreeRTOS/Source
    ../freertos/include/: FreeRTOS.h FreeRTOSConfig.h list.h portable.h portmacro.h
    ../freertos/: list.c task.c
  group doc
    ../Doc/: readm.txt
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.1
